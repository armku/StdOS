# Keil uVision project STDOSF1.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1,DEBUG,STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\STDOS;..\STDOS\Core;..\STDOS\Device;..\STDOS\Kernel;..\SYSTEM\STM32F1\CMSIS;..\SYSTEM\STM32F1\FWLib\inc;..\Util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.cpp
  group CMSIS
    ../SYSTEM/STM32F1/CMSIS/: core_cm3.c system_stm32f10x.c
  group Util
    ../Util/: CheckSum.cpp Util.cpp ModBus1.cpp
  group FWLIB
    ../SYSTEM/STM32F1/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: readme.txt 端口功能.txt 端口分配.txt
  group App
    ../STDOS/App/: ACZero.cpp Alarm.cpp BlinkPort.cpp Button.cpp Button_GrayLevel.cpp Button_magnetic.cpp CommandPort.cpp FlushPort.cpp IR.cpp IRcoding.cpp PowerUps.cpp PulsePort.cpp Raster.cpp Sensor.cpp Sound.cpp
  group Core
    ../STDOS/Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp TimeSpan.cpp List.cpp Type.cpp Random.cpp Delegate.cpp Queue.cpp Stream.cpp Dictionary.cpp SString.cpp LinkedList.cpp Environment.cpp EventHandler.cpp Version.cpp
  group Device
    ../STDOS/Device/: ADC.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Port.cpp Power.cpp ProxyConfig.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp UTPort.cpp WatchDog.cpp Readme.MD
  group Drivers
    ../STDOS/Drivers/: ADS1246.cpp NPA.cpp AD7689.cpp Button.cpp ST7565R.cpp W25QXXX.cpp AT24CXX.cpp BufferPort.cpp font.c lcd_dr.cpp AT45DB.cpp Readme.MD RX8025T.cpp AD7124.cpp
    ../STDOS/Drivers/Esp8266/: WaitExpect.cpp
  group STDOS
    ../STDOS/: Config.cpp BootConfig.cpp
  group Kernel
    ../STDOS/Kernel/: TTime.cpp WaitHandle.cpp Task.cpp TInterrupt.cpp Sys.cpp Heap.cpp Thread.cpp Readme.MD
  group Net
    ../STDOS/Net/: ITransport.cpp
  group Platform
    ../STDOS/Platform/STM32F1/: startup_stm32f10x_hd.s ADC.cpp Boot_F1.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Interrupt.cpp Port.cpp Power.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp
  group CortexM
    ../STDOS/Platform/CortexM/: Interrupt.cpp Port.cpp Runtime.cpp SerialPort.cpp Sys.cpp Thread.cpp Time.cpp
  group Storage
    ../STDOS/Storage/: Storage.cpp
  group Security
    ../STDOS/Security/: RC4.cpp AES.cpp Crc.cpp MD5.cpp RC6.cpp RSA.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c include: ..\SYSTEM\FWLib\inc;..\SYSTEM\Basic\inc;..\SYSTEM\CORE\inc;..\SYSTEM\OS\inc;..\SYSTEM\USMART\inc;..\SYSTEM\Util\inc;..\SYSTEM\CMSIS;..\SYSTEM\Devices\inc;..\UserDriver\inc;..\User\inc;..\SYSTEM\NET\inc;..\SYSTEM\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
