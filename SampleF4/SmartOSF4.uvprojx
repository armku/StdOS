# Keil uVision project SmartOSF4.uvprojx, settings and files
target SmartOSF1_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOSF1_Debug
  AfterMake: XScript.exe Build.cs /NoLogo /NoTime /NoStop /Hide
  c flags: Optim=1 OneElfS=1
  c define: STM32F1,DEBUG,USE_FULL_ASSERT
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\Device;..\SmartOS\Kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.cpp
  group CMSIS
    ../SYSTEM/CMSIS/: core_cm3.c system_stm32f10x.c
  group Util
    ../Util/: CheckSum.cpp ModBus1.cpp NewDelete.cpp Util.cpp
  group DOC
    ../Doc/: readme.txt 端口分配.txt 端口功能.txt
  group Core
    ../STDOS/Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp Delegate.cpp Dictionary.cpp Environment.cpp EventHandler.cpp LinkedList.cpp List.cpp Queue.cpp Random.cpp SString.cpp Stream.cpp TimeSpan.cpp Type.cpp Version.cpp
  group Device
    ../STDOS/Device/: ADC.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Port.cpp Power.cpp Proxy.cpp ProxyConfig.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp UTPort.cpp WatchDog.cpp
  group Drivers
    ../STDOS/Drivers/: ADS1246.cpp NPA.cpp AD7689.cpp Button.cpp ST7565R.cpp W25QXXX.cpp AT24CXX.cpp BufferPort.cpp lcd_dr.cpp
  group Kernel
    ../STDOS/Kernel/: Heap.cpp Sys.cpp Task.cpp Thread.cpp TInterrupt.cpp TTime.cpp WaitHandle.cpp
  group Net
    ../STDOS/Net/: ITransport.cpp
  group Storage
    ../STDOS/Storage/: Storage.cpp
  group Security
    ../STDOS/Security/: AES.cpp Crc.cpp MD5.cpp RC4.cpp RC6.cpp RSA.cpp
target SmartOSF1_RTM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: SmartOSF1_RTM
  AfterMake: XScript.exe Build.cs /NoLogo /NoTime /NoStop /Hide
  c flags: Optim=4 OneElfS=1
  c define: STM32F1
  c misc: --cpp11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
