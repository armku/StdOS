# Keil uVision project STDOSF1.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STD
  BeforeMake: D:\Job\Git\STDOS\SampleF1\GenCompileDate.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4,DEBUG,STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\STDOS;..\STDOS\Core;..\STDOS\Device;..\STDOS\Kernel;..\SYSTEM\STM32F4\CMSIS;..\SYSTEM\STM32F4\FWLIB\inc;..\Util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp
  group startup
    ../SYSTEM/STM32F4/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../SYSTEM/STM32F4/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group Util
    ../Util/: CheckSum.cpp NewDelete.cpp Util.cpp ModBus1.cpp
  group FWLIB
    ../SYSTEM/STM32F4/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../Doc/: readme.txt 端口功能.txt 端口分配.txt
  group App
    ../STDOS/App/: ACZero.cpp Alarm.cpp BlinkPort.cpp Button.cpp Button_GrayLevel.cpp Button_magnetic.cpp CommandPort.cpp FlushPort.cpp IR.cpp IRcoding.cpp PowerUps.cpp PulsePort.cpp Raster.cpp Sensor.cpp Sound.cpp
  group Core
    ../STDOS/Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp TimeSpan.cpp List.cpp Type.cpp Random.cpp Delegate.cpp Queue.cpp Stream.cpp Dictionary.cpp SString.cpp LinkedList.cpp Environment.cpp EventHandler.cpp Version.cpp
  group Device
    ../STDOS/Device/: ADC.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Port.cpp Power.cpp ProxyConfig.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp UTPort.cpp WatchDog.cpp
  group Drivers
    ../STDOS/Drivers/: ADS1246.cpp NPA.cpp AD7689.cpp Button.cpp ST7565R.cpp W25QXXX.cpp AT24CXX.cpp BufferPort.cpp font.c lcd_dr.cpp
    ../STDOS/Drivers/Esp8266/: WaitExpect.cpp
  group Kernel
    ../STDOS/Kernel/: TTime.cpp WaitHandle.cpp Task.cpp TInterrupt.cpp Sys.cpp Heap.cpp Thread.cpp
  group Net
    ../STDOS/Net/: ITransport.cpp
  group Platform
    ../STDOS/: BootConfig.cpp Config.cpp
  group Storage
    ../STDOS/Storage/: Storage.cpp
  group Security
    ../STDOS/Security/: RC4.cpp AES.cpp Crc.cpp MD5.cpp RC6.cpp RSA.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c include: ..\SYSTEM\FWLib\inc;..\SYSTEM\Basic\inc;..\SYSTEM\CORE\inc;..\SYSTEM\OS\inc;..\SYSTEM\USMART\inc;..\SYSTEM\Util\inc;..\SYSTEM\CMSIS;..\SYSTEM\Devices\inc;..\UserDriver\inc;..\User\inc;..\SYSTEM\NET\inc;..\SYSTEM\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
