# Keil uVision project STDOSF4Emwin.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4,DEBUG,STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\STDOS;..\STDOS\Core;..\STDOS\Device;..\STDOS\Kernel;..\SYSTEM\STM32F4\CMSIS;..\SYSTEM\STM32F4\FWLIB\inc;..\Util;..\User;..\User\bsp_stm32f4xx\inc;..\User\bsp_stm32f4xx;..\emWin\GUI_X;..\emWin\Config;..\emWin\Include;..\emWin\emWinTask
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp
    ../User/: SRamTest.cpp
  group CMSIS
    ../SYSTEM/STM32F4/CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../SYSTEM/STM32F4/FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_wwdg.c
  group DOC
    ../Doc/: readme.txt 端口功能.txt 端口分配.txt
  group Core
    ../STDOS/Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp List.cpp Queue.cpp Stream.cpp String.cpp Type.cpp Version.cpp
  group Device
    ../STDOS/Device/: Flash.cpp I2C.cpp Port.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp
  group Drivers
    ../STDOS/Drivers/: AD7124.cpp AD7689.cpp ADS1232.cpp ADS1246.cpp AT24CXX.cpp AT45DB.cpp lcd_dr.cpp NPA.cpp RX8025T.cpp ST7565R.cpp W25QXXX.cpp SSD1106.cpp SSD1309.cpp DS18B20.cpp bspkey.cpp
  group Fonts
    ../User/fonts/: font.c ssd1309bmp.c asc16.c hz12.c asc12.c ra8875_asc_width.c hz24.c hz16.c hz32.c ssd1309font.c
  group Kernel
    ../STDOS/Kernel/: Sys.cpp Task.cpp TInterrupt.cpp TTime.cpp
  group Net
    ../STDOS/Net/: ITransport.cpp
  group Platform
    ../SYSTEM/STM32F4/startup/: startup_stm32f40_41xxx.s
    ../STDOS/Platform/STM32F4/: Flash.cpp I2C.cpp Interrupt.cpp Port.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp FSMC.cpp
  group CortxM
    ../STDOS/Platform/CortexM/: Interrupt.cpp Port.cpp Runtime.cpp SerialPort.cpp Sys.cpp Time.cpp
  group Storage
    ../STDOS/Storage/: Storage.cpp
  group Security
    ../STDOS/Security/: CheckSum.cpp Crc.cpp Parity.cpp
  group Test
    ../STDOS/Test/: AD1246Test.cpp AD7124Test.cpp ADS1232Test.cpp ArrayTest.cpp AT24CXXTest.cpp AT45DBTest.cpp BufferTest.cpp DateTimeTest.cpp FlashTest.cpp lcd_drTest.cpp ListTest.cpp RX8025TTest.cpp SerialTest.cpp ST7565RTest.cpp StreamTest.cpp StringTest.cpp TimerTest.cpp W25QXXXTest.cpp WatchDogTest.cpp SSD1309Test.cpp DS18B20Test.cpp bspkeytest.cpp
  group bsp
    ../User/bsp_stm32f4xx/: bsp.c
    ../User/bsp_stm32f4xx/src/: bsp_timer.c bsp_tim_pwm.c bsp_spi_bus.c bsp_i2c_gpio.c bsp_eeprom_24xx.c
  group LCDDRIVER
    ../User/bsp_stm32f4xx/src/: bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c bsp_ra8875_flash.c bsp_ra8875_port.c param.c
    ../emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI/X
    ../emWin/GUI_X/: GUI_X.c
  group GUI/CONFIG
    ../emWin/Config/: GUIConf.c LCDConf.c
  group GUI/DEMO
    ../emWin/emWinTask/: MainTask.c
  group GUI/Lib
    ../emWin/GUILib/: STemWin528_CM4_Keil_ot.lib
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c include: ..\SYSTEM\FWLib\inc;..\SYSTEM\Basic\inc;..\SYSTEM\CORE\inc;..\SYSTEM\OS\inc;..\SYSTEM\USMART\inc;..\SYSTEM\Util\inc;..\SYSTEM\CMSIS;..\SYSTEM\Devices\inc;..\UserDriver\inc;..\User\inc;..\SYSTEM\NET\inc;..\SYSTEM\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
