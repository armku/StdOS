# Keil uVision project STDOSF1.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEBUG +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1,DEBUG,STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\OnChip;..\SmartOS\Kernel;..\Libraries\STM32F1\CMSIS;..\Libraries\STM32F1\FWLib\inc;..\Util;..\User;..\SmartOS\Security;..\SmartOS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../HAL/STM32F1/: ARCH_UART.cpp Reset.c
    ../SmartOS/Drivers/SPI/AD7124/Example/: AD7124Demo.cpp
    ../SmartOS/Drivers/SPI/AD7689/Example/: AD7689Demo.cpp
    ../SmartOS/Drivers/SPI/W25QXXX/Example/: W25QXXXDemo.cpp
    ../SmartOS/Drivers/COM/Esp8266/Example/: Esp8266Demo.cpp
    ../SmartOS/Drivers/COM/ModbusLink/Example/: ModbusLinkDemo.cpp
    ../SmartOS/Drivers/SPI/SSD1309/Example/: font.c ssd1309font.c
    ../SmartOS/Drivers/ST7565R/Example/: lcd_dr.cpp
    ../SmartOS/Core/: RingBuffer.cpp
  group Bsp
    ../User/Bsp/: Bsp.cpp
  group BspPlatform
    ../User/BspPlatform/: BspPlatform.cpp Interrupt.cpp
    ../Libraries/STM32F1/startup/: startup_stm32f10x_md.s
    ../SmartOS/: main.cpp
  group CMSIS
    ../Libraries/STM32F1/CMSIS/: core_cm3.c system_stm32f10x.c
  group Util
    ../SmartOS/Util/: Util.cpp
  group FWLIB
    ../Libraries/STM32F1/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: Readme.MD
  group App
    ../SmartOS/App/: BlinkPort.cpp bspkey.cpp FlushPort.cpp LCDOCM.cpp PID.cpp Button_magnetic.cpp CommandPort.cpp IR.cpp IRcoding.cpp PulsePort.cpp Sensor.cpp
  group Core
    ../SmartOS/Core/: Type.cpp Buffer.cpp Array.cpp ByteArray.cpp String.cpp DateTime.cpp Delegate.cpp List.cpp Dictionary.cpp Environment.cpp Queue.cpp Random.cpp Stream.cpp TimeSpan.cpp Version.cpp
  group Device
    ../SmartOS/OnChip/: USART.cpp Spi.cpp
    ../SmartOS/Device/: Port.cpp PwmSolo.cpp WatchDog.cpp I2C.cpp Power.cpp ADC.cpp CAN.cpp DAC.cpp Flash.cpp DMA.cpp RTC.cpp
  group Drivers
    ../SmartOS/Drivers/ADS1232/: ADS1232.cpp
    ../SmartOS/Drivers/DS18B20/: DS18B20.cpp
    ../SmartOS/Drivers/DS1302/: DS1302.cpp
    ../SmartOS/Drivers/OCM240128/: OCM240128.cpp ocmtest.cpp
    ../SmartOS/Drivers/ST7565R/: ST7565R.cpp
    ../SmartOS/Drivers/I2C/AT24CXX/: AT24CXX.cpp
    ../SmartOS/Drivers/I2C/NPA/: NPA.cpp
    ../SmartOS/Drivers/I2C/PCF8563/: PCF8563.cpp
    ../SmartOS/Drivers/I2C/RX8025T/: RX8025T.cpp
    ../SmartOS/Drivers/SPI/AD7124/: AD7124.cpp
    ../SmartOS/Drivers/SPI/ADS1246/: ADS1246.cpp
    ../SmartOS/Drivers/SPI/W25QXXX/: W25QXXX.cpp
    ../SmartOS/Drivers/I2C/MCP3421/: MCP3421.cpp
    ../SmartOS/Drivers/SPI/AD7689/: AD7689.cpp
    ../SmartOS/Drivers/SPI/SSD1106/: SSD1106.cpp
    ../SmartOS/Drivers/SPI/SSD1309/: SSD1309.cpp
  group DriversCom
    ../SmartOS/Drivers/COM/GPS_S1216/: GPS_S1216.cpp
    ../SmartOS/Drivers/COM/ModbusLink/: ModbusLink.cpp ModbusRtuLinkMaster.cpp ModbusRtuLinkRtuSlave.cpp
    ../SmartOS/Drivers/COM/SHARP_PM2_5/: SHARP_PM2_5.cpp
    ../SmartOS/Drivers/COM/Esp8266/: Esp8266.cpp
    ../SmartOS/Drivers/COM/MQTT/: MqttLink.cpp
  group Kernel
    ../SmartOS/Kernel/: Interrupt.cpp Heap.cpp Sys.cpp Task.cpp Thread.cpp Time.cpp WaitHandle.cpp
  group Security
    ../SmartOS/Security/: CheckSum.cpp Crc.cpp Crc16.cpp Math.cpp Parity.cpp AES.cpp MD5.cpp RC4.cpp RC6.cpp
  group CortexM
    ../SmartOS/Platform/CortexM/: Interrupt.cpp Sys.cpp Runtime.cpp Time.cpp Thread.cpp Port.cpp
  group Platform
    ../SmartOS/Platform/STM32F1/: Port.cpp I2C.cpp Spi.cpp Power.cpp ADC.cpp CAN.cpp DAC.cpp Flash.cpp DMA.cpp RTC.cpp Interrupt.cpp Timer.cpp
  group Storage
    ../SmartOS/Storage/: Storage.cpp
  group Net
    ../SmartOS/Net/: HttpClient.cpp IPAddress.cpp IPEndPoint.cpp ITransport.cpp MacAddress.cpp NetUri.cpp Zigbee.cpp
  group TokenNet
    ../SmartOS/TokenNet/: TokenDevice.cpp
  group Message
    ../SmartOS/Message/: Api.cpp BinaryPair.cpp Controller.cpp DataStore.cpp Json.cpp Message.cpp MessageBase.cpp Pair.cpp WeakStore.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Release +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\OnChip;..\SmartOS\Kernel;..\Libraries\STM32F1\CMSIS;..\Libraries\STM32F1\FWLib\inc;..\Util;..\User;..\SmartOS\Security
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
