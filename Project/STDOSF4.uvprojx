# Keil uVision project STDOSF4.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STD
  AfterMake: MDKTimeHelper.exe Objects/STD.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4,DEBUG,STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\StdOS;..\StdOS\Core;..\StdOS\OnChip;..\StdOS\Kernel;..\Libraries\STM32F4\CMSIS;..\Libraries\STM32F4\FWLIB\inc;..\Util;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Bsp
    ../User/Bsp/: Bsp.cpp font.c ssd1309font.c
  group BspPlatform
    ../SYSTEM/STM32F4/startup/: startup_stm32f40_41xxx.s
    ../User/BspPlatform/: BspPlatform.cpp
  group CMSIS
    ../SYSTEM/STM32F4/CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../SYSTEM/STM32F4/FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_wwdg.c
  group DOC
    ../Doc/: Readme.MD
  group App
    ../Libraries/App/: BlinkPort.cpp bspkey.cpp FlushPort.cpp lcd_dr.cpp LCDOCM.cpp PID.cpp
  group Core
    ../Libraries/Core/: Buffer.cpp DateTime.cpp List.cpp
  group OnChip
    ../Libraries/OnChip/: Port.cpp PwmSolo.cpp Spi.cpp WatchDog.cpp
  group Kernel
    ../Libraries/Kernel/: Sys.cpp Task.cpp Time.cpp
  group Security
    ../Libraries/Security/: CheckSum.cpp Crc.cpp Math.cpp Parity.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c misc: --cpp11
  c include: ..\Libraries;..\Libraries\Core;..\Libraries\OnChip;..\Libraries\Kernel;..\SYSTEM\STM32F4\CMSIS;..\SYSTEM\STM32F4\FWLIB\inc;..\Util;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
