# Keil uVision project STDOSF0.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STD
  AfterMake: MDKTimeHelper.exe Objects/STD.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F0,DEBUG,STM32F072, USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\StdOS;..\StdOS\Core;..\StdOS\OnChip;..\StdOS\Kernel;..\Libraries\STM32F0\CMSIS;..\Libraries\STM32F0\FWLib\inc;..\Util;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000100 size 0x4000
  group Bsp
    ../User/Bsp/: font.c Bsp.cpp
  group BspPlatform
    ../SYSTEM/STM32F0/startup/: startup_stm32f072.s
    ../User/BspPlatform/: BspPlatform.cpp
  group CMSIS
    ../SYSTEM/STM32F0/CMSIS/: system_stm32f0xx.c
  group Util
    ../Libraries/Util/: Util.cpp
  group FWLIB
    ../SYSTEM/STM32F0/FWLib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group DOC
    ../Doc/: Readme.MD
  group App
    ../Libraries/App/: BlinkPort.cpp bspkey.cpp FlushPort.cpp lcd_dr.cpp LCDOCM.cpp PID.cpp
  group Core
    ../Libraries/Core/: Buffer.cpp DateTime.cpp List.cpp
  group OnChip
    ../Libraries/OnChip/: Port.cpp PwmSolo.cpp Spi.cpp WatchDog.cpp
  group Drivers
    ../Libraries/Drivers/: I2C.cpp
  group Kernel
    ../Libraries/Kernel/: Sys.cpp Task.cpp Time.cpp
  group Security
    ../Libraries/Security/: CheckSum.cpp Crc.cpp Math.cpp Parity.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,STM32F1
  c misc: --cpp11
  c include: ..\Libraries;..\Libraries\Core;..\Libraries\OnChip;..\Libraries\Kernel;..\SYSTEM\STM32F0\CMSIS;..\SYSTEM\STM32F0\FWLib\inc;..\Util;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
