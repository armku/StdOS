# Keil uVision project STD.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,DEBUG
  c include: ..\SYSTEM\STM32F10x_FWLib\inc;..\SYSTEM\Basic\inc;..\SYSTEM\CORE\inc;..\SYSTEM\OS\inc;..\SYSTEM\USMART\inc;..\SYSTEM\Util\inc;..\SYSTEM\MCU\inc;..\SYSTEM\Devices\inc;..\UserDriver\inc;..\User\inc;..\SYSTEM\NET\inc;..\SYSTEM\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.cpp
    ../User/src/: stm32f10x_it.c
  group UserDriver
    ../User/src/: spitest.cpp
  group Basic
    ../SYSTEM/Basic/src/: Type.cpp Object.cpp Buffer.cpp Array.cpp ByteArray.cpp CString.cpp Stream.cpp DateTime.cpp TimeSpan.cpp IList.cpp List.cpp IDictionary.cpp Dictionary.cpp Delegate.cpp Queue.cpp Random.cpp
  group CORE
    ../SYSTEM/CORE/src/: Sys.cpp TTime.cpp TimeWheel.cpp TimeCost.cpp SmartIRQ.cpp WaitHandle.cpp TaskScheduler.cpp Task.cpp TInterrupt.cpp NewDelete.cpp
  group Peripheral
    ../SYSTEM/Peripheral/src/: Port.cpp Spi.cpp HardSpi.cpp SoftSpi.cpp I2C.cpp SoftI2C.cpp Pwm.cpp WatchDog.cpp usart.c ITransport.cpp SerialPort.cpp STM32Rtc.cpp Timer.cpp Flash.cpp
    ../SYSTEM/NET/src/: ISocket.cpp
  group Devices
    ../SYSTEM/Devices/src/: AD7689.cpp ADS1246.cpp NPA.cpp W24xxx.cpp ST7565R.cpp multi_button.cpp ModBus.cpp W25QXXX.cpp
  group NET
    ../SYSTEM/NET/src/: ISocketHost.cpp DHCP.cpp DNS.cpp Tcp.cpp Udp.cpp
  group MCU
    ../SYSTEM/MCU/: startup_stm32f10x_md.s
    ../SYSTEM/MCU/src/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../SYSTEM/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Util
    ../SYSTEM/Util/src/: RC4.cpp Util.cpp
  group DOC
    ../Doc/: readme.txt 端口功能.txt 端口分配.txt
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: STD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\STM32F10x_FWLib\inc;..\SYSTEM\Basic\inc;..\SYSTEM\CORE\inc;..\SYSTEM\Util\inc;..\SYSTEM\MCU\inc;..\SYSTEM\Devices\inc;..\UserDriver\inc;..\User\inc;..\SYSTEM\NET\inc;..\SYSTEM\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
